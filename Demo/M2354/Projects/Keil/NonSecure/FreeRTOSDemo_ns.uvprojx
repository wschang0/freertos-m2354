# Keil uVision project FreeRTOSDemo_ns.uvprojx, settings and files
target FreeRTOSDemo_ns (6180000::V6.18::ARMCLANG)
  device: M2354KJFAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOSDemo_ns +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: sign.bat
  c flags: OneElfS=1 v6Lang=3
  c define: DEBUG_PORT=UART0_NS,TFM_PARTITION_LOG_LEVEL=2,ITS_MAX_ASSET_SIZE=512,TFM_SP_LOG_RAW_ENABLED=1
  c include: ..\..\..\Nuvoton_Code\CMSIS\Include;..\..\..\Nuvoton_Code\Device\Nuvoton\M2354\Include;..\..\..\Nuvoton_Code\StdDriver\inc;..\Config;..\..\..\..\..\Source\include;..\..\..\..\Common\include;..\..\..\..\..\Source\portable\GCC\ARM_CM23_NTZ\non_secure;d:\out\m2354\install\interface\include;..\..\..\..\..\..\TF-M_Review\tfm_test_repo-src\test\framework;..\..\..\..\..\..\TF-M_Review\tfm_test_repo-src\ns_interface;..\..\..\..\..\..\TF-M_Review\trusted-firmware-m\secure_fw\partitions\lib\sprt\include;..\..\..\..\..\..\TF-M_Review\trusted-firmware-m\secure_fw\spm\include;..\..\..\..\..\..\TF-M_Review\trusted-firmware-m\platform\include;..\..\..\..\..\..\TF-M_Review\trusted-firmware-m\platform\ext\common;..\..\..\..\..\..\TF-M_Review\trusted-firmware-m\secure_fw\spm\cmsis_func\include;..\..\..\..\..\..\TF-M_Review\trusted-firmware-m\platform\ext\target\nuvoton\m2354\device\include;..\..\..\..\..\..\TF-M_Review\trusted-firmware-m\platform\ext\target\nuvoton\m2354\bsp\Device\Nuvoton\M2354\Include;..\..\..\..\..\..\TF-M_Review\trusted-firmware-m\platform\ext\target\nuvoton\m2354\bsp\Library\StdDriver\inc;..\..\..\..\..\..\TF-M_Review\trusted-firmware-m\platform\ext\cmsis;..\..\..\..\..\..\TF-M_Review\trusted-firmware-m\platform\ext\target\nuvoton\common\bsp\StdDriver\inc;..\..\..\..\..\..\TF-M_Review\tfm_test_repo-src\test\test_services\tfm_core_test;D:\out\install\interface\include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: FreeRTOSDemo_ns.sct
  group Config
    ../Config/: FreeRTOSConfig.h
  group Device
    ../../../Nuvoton_Code/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../../Nuvoton_Code/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
  group Drivers
    ../../../Nuvoton_Code/StdDriver/src/: gpio.c clk.c
  group FreeRTOS
    ../../../../../Source/: event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../../../../Source/portable/MemMang/: heap_4.c
    ../../../../../Source/portable/Common/: mpu_wrappers.c
    ../../../../../Source/portable/GCC/ARM_CM23/non_secure/: portasm.h portmacro.h
    ../../../../../Source/portable/GCC/ARM_CM23_NTZ/non_secure/: port.c portasm.c
  group Demos
    ./: main-blinky.c ParTest_M2354.c
  group User
    ./: main_ns.c os_wrapper_freertos.c tfm_ns_interface.c myretarget.c
    d:/out/m2354/install/interface/lib/: s_veneers.o
    D:/out/m2354/platform/target/: libtfm_regression_ns.a
    D:/out/m2354/app/: libtfm_api_ns.a libtfm_ns_integration_test.a
    D:/out/m2354/ns_log/: libtfm_ns_log.a
    D:/out/m2354/test/suites/qcbor/: libtfm_qcbor_ns.a libtfm_qcbor_test.a libtfm_test_suite_qcbor_ns.a
    D:/out/m2354/test/suites/t_cose/: libtfm_t_cose_test.a libtfm_test_suite_t_cose_ns.a
    D:/out/m2354/test/suites/attestation/: libtfm_test_suite_attestation_ns.a
    D:/out/m2354/test/suites/core/: libtfm_test_suite_core_ns.a
    D:/out/m2354/test/suites/crypto/: libtfm_test_suite_crypto_ns.a
    D:/out/m2354/test/suites/ipc/: libtfm_test_suite_ipc_ns.a
    D:/out/m2354/test/suites/its/: libtfm_test_suite_its_ns.a
    D:/out/m2354/test/suites/platform/: libtfm_test_suite_platform_ns.a
    C:/M2354_v1/trusted-firmware-m-m2354/build/test/suites/ps/: libtfm_test_suite_ps_ns.a
